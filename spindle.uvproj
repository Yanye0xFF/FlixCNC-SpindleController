# Keil uVision project spindle.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: spindle +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c stdint.h HC89S003F4.h hc89s_pwmgroup.h hc89s_pwmgroup.c hc89s_timer3.h hc89s_timer3.c hc89s_exit.c hc89s_exit.h hc89s_softi2c.c hc89s_softi2c.h hc89s_timer0.c hc89s_timer0.h hc89s_gpio.c hc89s_gpio.h
